## boards/shields/cfang/Kconfig.defconfig
```kconfig
if SHIELD_CFANG

config ZMK_KEYBOARD_NAME
    default "c-fang"

endif # SHIELD_CFANG
```
